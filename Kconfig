## Kconfig
```kconfig
# Copyright (c) 2022 T-Mobile USA, Inc.
#
# SPDX-License-Identifier: Apache-2.0

config CXD5605_LIB
    bool "Include CXD5605 library"
```
